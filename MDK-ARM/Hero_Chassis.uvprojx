# Keil uVision project Hero_Chassis.uvprojx, settings and files
target Hero_Chassis (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Hero_Chassis.elf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F427xx,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../User/App/chassis;../User/Bsp/can;../User/Bsp/dwt;../User/Bsp/usart;../User/Modules/arm_math;../User/Modules/message_center;../User/Modules/motor/dji_motor;../User/Modules/referee;../User/App/motor_task;../User/App/robot_cmd;../User/Modules/daemon;../User/Modules/motor/dm_motor;../User/Modules/motor;../User/Bsp/pwm;../User/Modules/buzzer;../User/Modules/remote_control;../User/Bsp/flash;../User/App/calibrate;../User/Bsp/gpio;../User/Bsp/spi;../User/Modules/algorithm;../User/Modules/mpu6500;../User/Modules/motor/unitree_motor;../User/App/robotarm;../User/App/robot;../User/Modules/custom_control;../User/Modules/airpump;../User/Modules/motor/rmd_motor;../User/Modules/motor/MG996;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src;../Middlewares/ST/STM32_USB_Device_Library/Core/Src;../User/Bsp/usb;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;..\User\Modules\fliter;..\User\App\cmd_receive;..\User\Modules\can_comm;..\User\App\target
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c crc.c dma.c rng.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Bsp
    ../User/Bsp/can/: bsp_can.c
    ../User/Bsp/dwt/: bsp_dwt.c
    ../User/Bsp/usart/: bsp_usart.c
    ../User/Bsp/pwm/: bsp_pwm.c
    ../User/Bsp/flash/: bsp_flash.c
    ../User/Bsp/gpio/: bsp_gpio.c
    ../User/Bsp/spi/: bsp_spi.c
    ../User/Bsp/usb/: bsp_usb.c
  group Modules
    ../User/Modules/message_center/: message_center.c
    ../User/Modules/referee/: crc_ref.c referee_UI.c rm_referee.c referee_task.c
    ../User/Modules/algorithm/: crc8.c user_lib.c kalman_filter.c MahonyAHRS.c QuaternionEKF.c controller.c
    ../User/Modules/arm_math/: arm_cortexM4lf_math.lib Custom_arm_math.c
    ../User/Modules/daemon/: daemon.c
    ../User/Modules/motor/dji_motor/: dji_motor.c
    ../User/Modules/motor/dm_motor/: dm_motor.c
    ../User/Modules/buzzer/: buzzer.c
    ../User/Modules/mpu6500/: imu_temperature.c mpu6500.c mpu6500driver.c
    ../User/Modules/motor/unitree_motor/: unitree_motor.c
    ../User/Modules/remote_control/: remote_control.c
    ../User/Modules/airpump/: airpump.c
    ../User/Modules/motor/rmd_motor/: rmd_motor.c
    ../User/Modules/motor/MG996/: MG996.c
    ../User/Modules/fliter/: fliter.c
    ../User/Modules/can_comm/: can_comm.c
  group App
    ../User/App/robot/: robot_task.h robot.c robot_def.h
    ../User/App/chassis/: chassis.c
    ../User/App/motor_task/: motor_task.c
    ../User/App/robot_cmd/: robot_cmd.c
    ../User/App/calibrate/: calibrate.c
    ../User/App/cmd_receive/: cmd_receive.c
    ../User/App/target/: target.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
